# Keil uVision project asp.uvproj, settings and files
target asp (ARM-ADS)
  device: LM3S6965 Texas Instruments
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(6000000) CPUTYPE("Cortex-M3")
  output: asp
  AfterMake: fromelf --m32combined asp.axf --output=asp.srec
  AfterMake: ../../../cfg/cfg/cfg --pass 3 --kernel asp -I. -I../../../ -I../../../include -I../../../arch -I../..  -I../../../target/cq_frk_fm3_armcc -I../../../arch/arm_m_armcc/common -I../../../arch/arm_m_gcc/common -I../../../target/cq_frk_fm3_gcc --rom-image asp.srec --symbol-table asp.syms -T ../../../target/cq_frk_fm3_armcc/target_check.tf --api-table ../../../kernel/kernel_api.csv --cfg1-def-table ../../../kernel/kernel_def.csv  --cfg1-def-table ../../../arch/arm
  c flags: Optim=1
  c misc: --diag_style=gnu --gnu --bss_threshold=0
  c include: ;.;../../../include;../../../arch;../../.. ;../../../target/cq_frk_fm3_armcc;../../../arch/arm_m_armcc/common;../../../arch/arm_m_gcc/common;../../../target/cq_frk_fm3_gcc;../../../kernel;../../../sample
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: ..\..\..\target\cq_frk_fm3_armcc\cq_frk_fm3_rom.scat
  link misc: --diag_style=gnu --datacompressor=off --no_remove --entry=_start  --symdefs=asp.syms libkernel.lib
  group app
    ../../../sample/: sample1.c
  group syssvc
    ../../../target/cq_frk_fm3_gcc/: target_serial.c
    ../../../syssvc/: banner.c logtask.c serial.c syslog.c vasyslog.c
    ../../../library/: log_output.c strerror.c t_perror.c
  group kernel
    ./: kernel_cfg.c
    ../../../arch/arm_m_armcc/common/: start.sx
