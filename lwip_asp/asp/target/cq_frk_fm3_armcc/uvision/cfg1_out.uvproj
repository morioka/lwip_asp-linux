# Keil uVision project cfg1_out.uvproj, settings and files
target cfg1_out (ARM-ADS)
  device: LM3S6965 Texas Instruments
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(6000000) CPUTYPE("Cortex-M3")
  output: cfg1_out
  BeforeMake: ../../../cfg/cfg/cfg --pass 1 --kernel asp -I. -I../../../ -I../../../include -I../../../arch -I../../..  -I../../../target/cq_frk_fm3_armcc -I../../../arch/arm_m_armcc/common -I../../../arch/arm_m_gcc/common -I../../../target/cq_frk_fm3_gcc --api-table ../../../kernel/kernel_api.csv --cfg1-def-table ../../../kernel/kernel_def.csv  --cfg1-def-table ../../../arch/arm_m_gcc/common/core_def.csv ../../../sample/sample1.cfg
  AfterMake: fromelf --m32combined cfg1_out.axf --output=cfg1_out.srec
  AfterMake: ../../../cfg/cfg/cfg --pass 2 --kernel asp -I. -I../../.. -I../../../include -I../../../arch -I../..  -I../../../target/cq_frk_fm3_armcc -I../../../arch/arm_m_armcc/common -I../../../arch/arm_m_gcc/common -I../../../target/cq_frk_fm3_gcc -T ../../../target/cq_frk_fm3_armcc/target.tf --api-table ../../../kernel/kernel_api.csv --cfg1-def-table ../../../kernel/kernel_def.csv  --cfg1-def-table ../../../arch/arm_m_gcc/common/core_def.csv ../../../sample/sample1.cfg
  c flags: Optim=1
  c misc: --diag_style=gnu --gnu --bss_threshold=0
  c include: ;.;../../../;../../../include;../../../arch;../../.. ;../../../target/cq_frk_fm3_armcc;../../../arch/arm_m_armcc/common;../../../arch/arm_m_gcc/common;../../../target/cq_frk_fm3_gcc;../../../kernel;../../../sample
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: ..\cq_frk_fm3_rom.scat
  link misc: --diag_style=gnu --datacompressor=off --symdefs=cfg1_out.syms --no_remove
  group cfg
    ../../../sample/: sample1.cfg
  group src
    ./: cfg1_out.c
