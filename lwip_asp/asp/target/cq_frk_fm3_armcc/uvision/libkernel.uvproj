# Keil uVision project libkernel.uvproj, settings and files
target libkernel (ARM-ADS)
  device: LM3S6965 Texas Instruments
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(6000000) CPUTYPE("Cortex-M3")
  output: libkernel (library)
  BeforeMake: ../../../cfg/cfg/cfg --pass 3 --kernel asp -I.-I../../.. -I./src -I../../../include -I../../../arch -I../../..  -I../../../target/cq_frk_fm3_armcc -I../../../arch/arm_m_armcc/common -I../../../arch/arm_m_gcc/common -I../../../target/cq_frk_fm3_gcc --rom-image cfg1_out.srec --symbol-table cfg1_out.syms -T ../../../target/cq_frk_fm3_gcc/target_offset.tf --api-table ../../../kernel/kernel_api.csv --cfg1-def-table ../../../kernel/kernel_def.csv  --cfg1-def-table ../../../arch/arm_m_gcc/common/core_def.csv ../../../sample/sample1.cfg
  c flags: Optim=4
  c misc: --diag_style=gnu --gnu --bss_threshold=0 -DALLFUNC
  c include: ;.;../../../;../../../include;../../../arch;../../.. ;../../../target/cq_frk_fm3_armcc;../../../arch/arm_m_armcc/common;../../../arch/arm_m_gcc/common;../../../target/cq_frk_fm3_gcc;../../../kernel;
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group kernel
    ../../../kernel/: alarm.c cyclic.c dataqueue.c eventflag.c exception.c interrupt.c mailbox.c mempfix.c pridataq.c semaphore.c startup.c sys_manage.c task.c task_except.c task_manage.c task_refer.c task_sync.c time_event.c time_manage.c wait.c
  group arch
    ../../../arch/arm_m_armcc/common/: core_support.sx
    ../../../arch/arm_m_gcc/common/: core_config.c core_timer.c
  group target
    ../../../target/cq_frk_fm3_gcc/: target_config.c
